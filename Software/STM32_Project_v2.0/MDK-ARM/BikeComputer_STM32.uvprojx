# Keil uVision project BikeComputer_STM32.uvprojx, settings and files
target BikeComputer_STM32 (6070000::V6.7::.\ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: BikeComputer_STM32 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx,UI_TARGET_STM32=1,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../App/BSP;../App/Common;../App/Config;../App/Device;../App/Protocol;../App/RTOS;../App/System;../App/Service;../../Lvgl_Project/src;../../Lvgl_Project;../../Lvgl_Project/lvgl;../../Lvgl_Project/config/stm32
  asm include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\BikeComputer_STM32\BikeComputer_Memory.sct
  link misc: "..\..\Lvgl_Project\build-stm32-host\q4-arm\libbike_ui_stm32.a" "..\..\Lvgl_Project\build-stm32-host\q4-arm\lib\liblvgl.a" "..\..\Lvgl_Project\build-stm32-host\q4-arm\lib\liblvgl_thorvg.a"
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c dma2d.c fmc.c i2c.c ltdc.c quadspi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_dma2d.c stm32h7xx_ll_fmc.c stm32h7xx_hal_nor.c stm32h7xx_hal_sram.c stm32h7xx_hal_nand.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_ltdc_ex.c stm32h7xx_hal_dsi.c stm32h7xx_hal_qspi.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM4F/: port.c
  group App_BSP
    ../App/BSP/: bsp_uart.c bsp_uart.h bsp_adc.c bsp_adc.h bsp_lcd.c bsp_lcd.h bsp_sdram.c bsp_sdram.h bsp_input.c bsp_input.h bsp_gnss.c bsp_gnss.h bsp_dma2d.c bsp_dma2d.h bsp_qspi.c bsp_qspi.h bsp_spl06.c bsp_spl06.h
  group APP_Device
    ../App/Device/: gnss.c gnss.h
  group App_service
    ../App/Service/: input_router.c input_router.h input_service.c input_service.h resource_manager.c resource_manager.h resource_package.c resource_package.h resource_storage.c resource_storage.h ride_recorder.c ride_recorder.h sensor_fusion.c sensor_fusion.h battery_service.c battery_service.h gnss_service.c gnss_service.h sensor_service.c sensor_service.h altitude_service.c altitude_service.h
  group App_System
    ../App/System/: app_main.c app_main.h power_service.c power_service.h ui_display.c ui_display.h ui_board.c ui_board.h ui_gnss_bridge.c ui_gnss_bridge.h ui_altitude_bridge.c ui_altitude_bridge.h
  group App_RTOS
    ../App/RTOS/: app_rtos.c app_rtos.h
  group App_Common
    ../App/Common/: app_events.h app_types.h
  group Resource installation
    ../App/BSP/: bsp_resource_boot.c bsp_resource_boot.h
    ../App/Service/: resource_install.c resource_install.h
    ../App/System/: resource_system.c resource_system.h
software components: CMSIS:CORE 5.0.1
